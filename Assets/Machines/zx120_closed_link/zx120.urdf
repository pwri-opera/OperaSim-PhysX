Commit message: Set arm cyl position

File: Assets/Machines/zx120_closed_link/zx120.urdf (robot description, URDF)
Before this commit: robot zx120, 14 links, 13 joints
Joints:
- joint joint7: origin xyz=2.053030 0 1.991444 -> xyz=2.053030 0 1.991444 rpy=0 -0.156207 0
